# Keil uVision project atk_f103.uvprojx, settings and files
target Template (6160000::V6.16::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  group Startup
    ../../Users/: startup_stm32f103xe.s
  group User
    ../../Users/: main.c
    ../../../../out/install/gcc/lib/: libstm32f103-hal.a libMain.a libhal-wrapper.a libatk-stm32f103.a
